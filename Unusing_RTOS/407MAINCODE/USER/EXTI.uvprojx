# Keil uVision project EXTI.uvprojx, settings and files
target DEMO (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EXTI +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\FWLIB\inc;..\HARDWARE\RELAY;..\HARDWARE\DHT11;..\HARDWARE\OLED;..\HARDWARE\MTF01;..\HARDWARE\ASRPRO;..\HARDWARE\ESP8266;..\HARDWARE\NCLLDS;..\HARDWARE\SOIL_MOISTURE;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/DHT11/: bsp_dht11.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/MTF01/: mtf01.c
    ../HARDWARE/ASRPRO/: asrpro.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/NCLLDS/: ncllds.c
    ../HARDWARE/SOIL_MOISTURE/: Soil_moisture.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_tim.c
  group README
    ../: readme.txt
