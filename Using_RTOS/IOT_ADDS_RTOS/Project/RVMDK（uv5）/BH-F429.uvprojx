# Keil uVision project BH-F429.uvprojx, settings and files
target FreeRTOS_TP (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_TP +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\prot\RVDS\ARM_CM4F;..\..\HARDWARE\LED;..\..\HARDWARE\USART;..\..\HARDWARE\KEY;..\..\HARDWARE\EXTI;..\..\User\DELAY;..\..\User\FONT;..\..\User\SYSTICK;..\..\HARDWARE\DHT11;..\..\HARDWARE\FLASH;..\..\HARDWARE\LCD;..\..\HARDWARE\SDRAM;..\..\HARDWARE\ASRPRO;..\..\HARDWARE\BH1750;..\..\HARDWARE\ESP8266;..\..\HARDWARE\MTF01;..\..\HARDWARE\NCLLDS;..\..\HARDWARE\OLED;..\..\HARDWARE\RELAY;..\..\HARDWARE\SOIL_MOISTURE;..\..\HARDWARE\TIMER;..\..\HARDWARE\TOUCH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
    ../../User/DELAY/: core_delay.c
    ../../User/SYSTICK/: bsp_SysTick.c
    ../../User/FONT/: fonts.c
  group DOC
    ../../: Readme.txt
  group FreeRTOS_port
    ../../FreeRTOS/prot/MemMang/: heap_4.c
    ../../FreeRTOS/prot/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group HARDWARE
    ../../HARDWARE/LED/: bsp_led.c
    ../../HARDWARE/USART/: bsp_debug_usart.c
    ../../HARDWARE/KEY/: bsp_key.c
    ../../HARDWARE/EXTI/: bsp_exti.c
    ../../HARDWARE/DHT11/: bsp_dht11.c
    ../../HARDWARE/FLASH/: bsp_spi_flash.c
    ../../HARDWARE/LCD/: bsp_lcd.c
    ../../HARDWARE/SDRAM/: bsp_sdram.c
    ../../HARDWARE/ESP8266/: esp8266.c
